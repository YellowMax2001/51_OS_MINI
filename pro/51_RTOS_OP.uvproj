# Keil uVision project 51_RTOS_OP.uvproj, settings and files
target 51_OPS (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 51_RTOS_OP +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\head
  group Source
    ../src/: common.c eeprom.c interrupt_ctrl.c mode_set.c nt_led.c uart.c vector.c
  group main
    ../main/: main.c
