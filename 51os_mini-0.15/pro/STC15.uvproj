# Keil uVision project STC15.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: STC15 +hex
  c flags: Optimize=2 SizeSpeed=1
  c include: ../head;../board/head
  group main
    ../main/: main.c
  group src
    ../src/: common.c eeprom.c uart.c vector.c core.c task.c char.c structs.c
  group boardsrc
    ../board/src/: nt_led.c
  group head
    ../head/: common.h eeprom.h uart.h vector.h core.h task.h char.h structs.h
  group boardhead
    ../board/head/: nt_led.h
