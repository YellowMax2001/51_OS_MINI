# Keil uVision project STC15.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: STC15 +hex
  c flags: Optimize=2 SizeSpeed=1
  c include: ../head
  group main
    ../main/: main.c
  group src
    ../src/: common.c eeprom.c nt_led.c uart.c vector.c core.c task.c
  group head
    ../head/: common.h eeprom.h nt_led.h uart.h vector.h core.h task.h
